# Keil uVision project Sistema Embebido.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.2
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Sistema Embebido
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3
  c include: .\Inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group main
    ./Src/: main.c
  group functions
    ./Src/: PWM.c Fc_config_IRQ.c Fc_config_pines.c Fc_config_PWM.c Fc_config_TIMER.c Fc_bluetooth_communication.c Fc_speed_control.c
    ./Inc/: PWM.h Fc_config_IRQ.h Fc_config_pines.h Fc_config_TIMER.h Fc_config_PWM.h Fc_speed_control.h Fc_bluetooth_communication.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
